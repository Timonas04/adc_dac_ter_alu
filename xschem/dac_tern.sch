v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 820 -1060 820 -1020 {
lab=vss}
N 820 -1310 820 -1270 {
lab=vdd}
N 720 -730 860 -730 {
lab=#net1}
N 860 -790 970 -790 {
lab=#net2}
N 970 -790 970 -650 {
lab=#net2}
N 860 -650 970 -650 {
lab=#net2}
N 720 -710 860 -710 {
lab=#net3}
N 720 -610 1020 -610 {
lab=#net4}
N 720 -650 720 -640 {
lab=#net4}
N 700 -760 700 -680 {
lab=vss}
N 1050 -590 1110 -590 {
lab=vss}
N 700 -760 700 -680 {
lab=vss}
N 840 -790 840 -760 {
lab=vss}
N 840 -680 840 -640 {
lab=vss}
N 720 -910 860 -910 {
lab=#net5}
N 860 -970 970 -970 {
lab=#net6}
N 860 -830 970 -830 {
lab=#net6}
N 720 -890 860 -890 {
lab=#net7}
N 700 -940 700 -860 {
lab=vss}
N 700 -940 700 -860 {
lab=vss}
N 840 -970 840 -940 {
lab=vss}
N 720 -830 720 -790 {
lab=#net8}
N 970 -970 970 -830 {
lab=#net6}
N 840 -860 840 -790 {
lab=vss}
N 700 -860 700 -760 {
lab=vss}
N 1170 -590 1230 -590 {
lab=vss}
N 1110 -590 1170 -590 {
lab=vss}
N 720 -340 860 -340 {
lab=#net9}
N 860 -400 970 -400 {
lab=#net10}
N 970 -400 970 -260 {
lab=#net10}
N 860 -260 970 -260 {
lab=#net10}
N 720 -320 860 -320 {
lab=#net11}
N 700 -370 700 -290 {
lab=vss}
N 700 -370 700 -290 {
lab=vss}
N 840 -400 840 -370 {
lab=vss}
N 840 -290 840 -250 {
lab=vss}
N 720 -520 860 -520 {
lab=#net12}
N 860 -580 970 -580 {
lab=#net13}
N 860 -440 970 -440 {
lab=#net13}
N 720 -500 860 -500 {
lab=#net14}
N 700 -550 700 -470 {
lab=vss}
N 700 -550 700 -470 {
lab=vss}
N 840 -580 840 -550 {
lab=vss}
N 720 -440 720 -400 {
lab=#net15}
N 970 -580 970 -440 {
lab=#net13}
N 840 -470 840 -400 {
lab=vss}
N 700 -470 700 -370 {
lab=vss}
N 720 -640 720 -580 {
lab=#net4}
N 700 -290 700 -260 {
lab=vss}
N 700 -260 720 -260 {
lab=vss}
N 170 -860 310 -860 {
lab=#net16}
N 310 -920 420 -920 {
lab=#net17}
N 420 -920 420 -780 {
lab=#net17}
N 310 -780 420 -780 {
lab=#net17}
N 170 -840 310 -840 {
lab=#net18}
N 150 -890 150 -810 {
lab=vss}
N 150 -890 150 -810 {
lab=vss}
N 290 -920 290 -890 {
lab=vss}
N 290 -810 290 -770 {
lab=vss}
N 170 -1040 310 -1040 {
lab=#net19}
N 310 -1100 420 -1100 {
lab=#net20}
N 310 -960 420 -960 {
lab=#net20}
N 170 -1020 310 -1020 {
lab=#net21}
N 150 -1070 150 -990 {
lab=vss}
N 150 -1070 150 -990 {
lab=vss}
N 290 -1100 290 -1070 {
lab=vss}
N 170 -960 170 -920 {
lab=0v9}
N 420 -1100 420 -960 {
lab=#net20}
N 290 -990 290 -920 {
lab=vss}
N 150 -990 150 -890 {
lab=vss}
N 150 -810 150 -780 {
lab=vss}
N 150 -780 170 -780 {
lab=vss}
N 820 -1240 820 -1090 {
lab=#net22}
N 980 -1390 980 -1170 {}
N 720 -1170 720 -970 {}
N 720 -1170 820 -1170 {}
N 900 -1150 900 -1130 {}
N 1460 -1060 1460 -1020 {
lab=vss}
N 1460 -1310 1460 -1270 {
lab=vdd}
N 1360 -730 1500 -730 {
lab=#net1}
N 1500 -790 1610 -790 {
lab=#net2}
N 1610 -790 1610 -650 {
lab=#net2}
N 1500 -650 1610 -650 {
lab=#net2}
N 1360 -710 1500 -710 {
lab=#net3}
N 1360 -610 1660 -610 {
lab=#net4}
N 1360 -650 1360 -640 {
lab=#net4}
N 1340 -760 1340 -680 {
lab=vss}
N 1690 -590 1750 -590 {
lab=vss}
N 1340 -760 1340 -680 {
lab=vss}
N 1480 -790 1480 -760 {
lab=vss}
N 1480 -680 1480 -640 {
lab=vss}
N 1360 -910 1500 -910 {
lab=#net5}
N 1500 -970 1610 -970 {
lab=#net6}
N 1500 -830 1610 -830 {
lab=#net6}
N 1360 -890 1500 -890 {
lab=#net7}
N 1340 -940 1340 -860 {
lab=vss}
N 1340 -940 1340 -860 {
lab=vss}
N 1480 -970 1480 -940 {
lab=vss}
N 1360 -830 1360 -790 {
lab=#net8}
N 1610 -970 1610 -830 {
lab=#net6}
N 1480 -860 1480 -790 {
lab=vss}
N 1340 -860 1340 -760 {
lab=vss}
N 1810 -590 1870 -590 {
lab=vss}
N 1750 -590 1810 -590 {
lab=vss}
N 1460 -1240 1460 -1090 {
lab=#net22}
N 1620 -1390 1620 -1170 {}
N 1360 -1170 1360 -970 {}
N 1360 -1170 1460 -1170 {}
N 1540 -1150 1540 -1130 {}
N 1260 -610 1360 -610 {}
N 1360 -640 1360 -610 {}
N 2100 -1060 2100 -1020 {
lab=vss}
N 2100 -1310 2100 -1270 {
lab=vdd}
N 2000 -730 2140 -730 {
lab=#net1}
N 2140 -790 2250 -790 {
lab=#net2}
N 2250 -790 2250 -650 {
lab=#net2}
N 2140 -650 2250 -650 {
lab=#net2}
N 2000 -710 2140 -710 {
lab=#net3}
N 2000 -610 2300 -610 {
lab=#net4}
N 2000 -650 2000 -640 {
lab=#net4}
N 1980 -760 1980 -680 {
lab=vss}
N 2330 -590 2390 -590 {
lab=vss}
N 1980 -760 1980 -680 {
lab=vss}
N 2120 -790 2120 -760 {
lab=vss}
N 2120 -680 2120 -640 {
lab=vss}
N 2000 -910 2140 -910 {
lab=#net5}
N 2140 -970 2250 -970 {
lab=#net6}
N 2140 -830 2250 -830 {
lab=#net6}
N 2000 -890 2140 -890 {
lab=#net7}
N 1980 -940 1980 -860 {
lab=vss}
N 1980 -940 1980 -860 {
lab=vss}
N 2120 -970 2120 -940 {
lab=vss}
N 2000 -830 2000 -790 {
lab=#net8}
N 2250 -970 2250 -830 {
lab=#net6}
N 2120 -860 2120 -790 {
lab=vss}
N 1980 -860 1980 -760 {
lab=vss}
N 2450 -590 2510 -590 {
lab=vss}
N 2390 -590 2450 -590 {
lab=vss}
N 2100 -1240 2100 -1090 {
lab=#net22}
N 2260 -1390 2260 -1170 {}
N 2000 -1170 2000 -970 {}
N 2000 -1170 2100 -1170 {}
N 2180 -1150 2180 -1130 {}
N 1900 -610 2000 -610 {}
N 2000 -640 2000 -610 {}
N 2740 -1060 2740 -1020 {
lab=vss}
N 2740 -1310 2740 -1270 {
lab=vdd}
N 2640 -730 2780 -730 {
lab=#net1}
N 2780 -790 2890 -790 {
lab=#net2}
N 2890 -790 2890 -650 {
lab=#net2}
N 2780 -650 2890 -650 {
lab=#net2}
N 2640 -710 2780 -710 {
lab=#net3}
N 2640 -610 2940 -610 {
lab=#net4}
N 2640 -650 2640 -640 {
lab=#net4}
N 2620 -760 2620 -680 {
lab=vss}
N 2970 -590 3030 -590 {
lab=vss}
N 2620 -760 2620 -680 {
lab=vss}
N 2760 -790 2760 -760 {
lab=vss}
N 2760 -680 2760 -640 {
lab=vss}
N 2640 -910 2780 -910 {
lab=#net5}
N 2780 -970 2890 -970 {
lab=#net6}
N 2780 -830 2890 -830 {
lab=#net6}
N 2640 -890 2780 -890 {
lab=#net7}
N 2620 -940 2620 -860 {
lab=vss}
N 2620 -940 2620 -860 {
lab=vss}
N 2760 -970 2760 -940 {
lab=vss}
N 2640 -830 2640 -790 {
lab=#net8}
N 2890 -970 2890 -830 {
lab=#net6}
N 2760 -860 2760 -790 {
lab=vss}
N 2620 -860 2620 -760 {
lab=vss}
N 3090 -590 3150 -590 {
lab=vss}
N 3030 -590 3090 -590 {
lab=vss}
N 2740 -1240 2740 -1090 {
lab=#net22}
N 2900 -1390 2900 -1170 {}
N 2640 -1170 2640 -970 {}
N 2640 -1170 2740 -1170 {}
N 2820 -1150 2820 -1130 {}
N 2540 -610 2640 -610 {}
N 2640 -640 2640 -610 {}
N 3380 -1060 3380 -1020 {
lab=vss}
N 3380 -1310 3380 -1270 {
lab=vdd}
N 3280 -730 3420 -730 {
lab=#net1}
N 3420 -790 3530 -790 {
lab=#net2}
N 3530 -790 3530 -650 {
lab=#net2}
N 3420 -650 3530 -650 {
lab=#net2}
N 3280 -710 3420 -710 {
lab=#net3}
N 3280 -610 3580 -610 {
lab=#net4}
N 3280 -650 3280 -640 {
lab=#net4}
N 3260 -760 3260 -680 {
lab=vss}
N 3610 -590 3670 -590 {
lab=vss}
N 3260 -760 3260 -680 {
lab=vss}
N 3400 -790 3400 -760 {
lab=vss}
N 3400 -680 3400 -640 {
lab=vss}
N 3280 -910 3420 -910 {
lab=#net5}
N 3420 -970 3530 -970 {
lab=#net6}
N 3420 -830 3530 -830 {
lab=#net6}
N 3280 -890 3420 -890 {
lab=#net7}
N 3260 -940 3260 -860 {
lab=vss}
N 3260 -940 3260 -860 {
lab=vss}
N 3400 -970 3400 -940 {
lab=vss}
N 3280 -830 3280 -790 {
lab=#net8}
N 3530 -970 3530 -830 {
lab=#net6}
N 3400 -860 3400 -790 {
lab=vss}
N 3260 -860 3260 -760 {
lab=vss}
N 3730 -590 3790 -590 {
lab=vss}
N 3670 -590 3730 -590 {
lab=vss}
N 3380 -1240 3380 -1090 {
lab=#net22}
N 3540 -1390 3540 -1170 {}
N 3280 -1170 3280 -970 {}
N 3280 -1170 3380 -1170 {}
N 3460 -1150 3460 -1130 {}
N 3180 -610 3280 -610 {}
N 3280 -640 3280 -610 {}
N 4020 -1060 4020 -1020 {
lab=vss}
N 4020 -1310 4020 -1270 {
lab=vdd}
N 3920 -730 4060 -730 {
lab=#net1}
N 4060 -790 4170 -790 {
lab=#net2}
N 4170 -790 4170 -650 {
lab=#net2}
N 4060 -650 4170 -650 {
lab=#net2}
N 3920 -710 4060 -710 {
lab=#net3}
N 3920 -610 4220 -610 {
lab=#net4}
N 3920 -650 3920 -640 {
lab=#net4}
N 3900 -760 3900 -680 {
lab=vss}
N 3900 -760 3900 -680 {
lab=vss}
N 4040 -790 4040 -760 {
lab=vss}
N 4040 -680 4040 -640 {
lab=vss}
N 3920 -910 4060 -910 {
lab=#net5}
N 4060 -970 4170 -970 {
lab=#net6}
N 4060 -830 4170 -830 {
lab=#net6}
N 3920 -890 4060 -890 {
lab=#net7}
N 3900 -940 3900 -860 {
lab=vss}
N 3900 -940 3900 -860 {
lab=vss}
N 4040 -970 4040 -940 {
lab=vss}
N 3920 -830 3920 -790 {
lab=#net8}
N 4170 -970 4170 -830 {
lab=#net6}
N 4040 -860 4040 -790 {
lab=vss}
N 3900 -860 3900 -760 {
lab=vss}
N 4020 -1240 4020 -1090 {
lab=#net22}
N 4180 -1390 4180 -1170 {}
N 3920 -1170 3920 -970 {}
N 3920 -1170 4020 -1170 {}
N 4100 -1150 4100 -1130 {}
N 3820 -610 3920 -610 {}
N 3920 -640 3920 -610 {}
N 4180 -1390 4260 -1390 {}
N 4420 -1570 4420 -1390 {}
N 4340 -1550 4340 -1490 {}
N 4340 -1370 4340 -1310 {}
N 4340 -590 4340 -530 {}
N 4220 -610 4260 -610 {}
C {title.sym} 170 -40 0 0 {name=l1 author="Timonas Juonys"}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/vbuff.sym} 830 -1370 0 0 {name=x1}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/anl_switch.sym} 900 -1170 0 1 {name=x2}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 800 -1060 0 0 {name=M1
L=0.15
W=2
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 800 -1270 0 0 {name=M2
L=0.15
W=6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 820 -1310 2 0 {name=p6 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 820 -1020 2 0 {name=p7 sig_type=std_logic lab=vss}
C {ipin.sym} 120 -620 0 0 {name=p1 lab=vdd}
C {lab_pin.sym} 120 -620 0 1 {name=p2 sig_type=std_logic lab=vdd}
C {ipin.sym} 120 -120 0 0 {name=p5 lab=vss}
C {lab_pin.sym} 120 -120 0 1 {name=p8 sig_type=std_logic lab=vss}
C {ipin.sym} 120 -400 0 0 {name=p31 lab=t2m}
C {ipin.sym} 120 -380 0 0 {name=p32 lab=t2l}
C {ipin.sym} 120 -360 0 0 {name=p33 lab=t1h}
C {ipin.sym} 120 -340 0 0 {name=p34 lab=t1m}
C {ipin.sym} 120 -320 0 0 {name=p35 lab=t1l}
C {ipin.sym} 120 -300 0 0 {name=p36 lab=t0h}
C {ipin.sym} 120 -280 0 0 {name=p37 lab=t0m}
C {ipin.sym} 120 -260 0 0 {name=p38 lab=t0l}
C {opin.sym} 100 -140 0 0 {name=p3 lab=a0}
C {lab_pin.sym} 100 -140 2 1 {name=p40 sig_type=std_logic lab=a0}
C {lab_pin.sym} 120 -400 2 0 {name=p41 sig_type=std_logic lab=t2m}
C {lab_pin.sym} 120 -380 2 0 {name=p42 sig_type=std_logic lab=t2l}
C {lab_pin.sym} 120 -360 2 0 {name=p43 sig_type=std_logic lab=t1h}
C {lab_pin.sym} 120 -340 2 0 {name=p44 sig_type=std_logic lab=t1m}
C {lab_pin.sym} 120 -320 2 0 {name=p45 sig_type=std_logic lab=t1l}
C {lab_pin.sym} 120 -300 2 0 {name=p46 sig_type=std_logic lab=t0h}
C {lab_pin.sym} 120 -280 2 0 {name=p47 sig_type=std_logic lab=t0m}
C {lab_pin.sym} 120 -260 2 0 {name=p48 sig_type=std_logic lab=t0l}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 720 -760 0 0 {name=R76
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 720 -680 0 0 {name=R3
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 860 -760 0 0 {name=R4
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 860 -680 0 0 {name=R6
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1050 -610 3 0 {name=R7
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1110 -610 3 0 {name=R9
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 700 -680 2 1 {name=p75 sig_type=std_logic lab=vss}
C {lab_pin.sym} 840 -790 2 1 {name=p76 sig_type=std_logic lab=vss}
C {lab_pin.sym} 840 -640 2 1 {name=p77 sig_type=std_logic lab=vss}
C {ipin.sym} 120 -480 0 0 {name=p14 lab=t3h}
C {ipin.sym} 120 -460 0 0 {name=p15 lab=t3m}
C {ipin.sym} 120 -440 0 0 {name=p16 lab=t3l}
C {ipin.sym} 120 -420 0 0 {name=p17 lab=t2h}
C {lab_pin.sym} 120 -480 2 0 {name=p19 sig_type=std_logic lab=t3h}
C {lab_pin.sym} 120 -460 2 0 {name=p20 sig_type=std_logic lab=t3m}
C {lab_pin.sym} 120 -440 2 0 {name=p21 sig_type=std_logic lab=t3l}
C {lab_pin.sym} 120 -420 2 0 {name=p22 sig_type=std_logic lab=t2h}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 720 -940 0 0 {name=R14
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 720 -860 0 0 {name=R15
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 860 -940 0 0 {name=R16
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 860 -860 0 0 {name=R17
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 840 -970 2 1 {name=p13 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1170 -610 3 0 {name=R1
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1230 -610 3 0 {name=R2
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 1230 -590 2 0 {name=p9 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 720 -370 0 0 {name=R5
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 720 -290 0 0 {name=R8
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 860 -370 0 0 {name=R10
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 860 -290 0 0 {name=R11
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 700 -260 2 1 {name=p10 sig_type=std_logic lab=vss}
C {lab_pin.sym} 840 -400 2 1 {name=p11 sig_type=std_logic lab=vss}
C {lab_pin.sym} 840 -250 2 1 {name=p12 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 720 -550 0 0 {name=R12
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 720 -470 0 0 {name=R13
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 860 -550 0 0 {name=R18
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 860 -470 0 0 {name=R19
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 840 -580 2 1 {name=p18 sig_type=std_logic lab=vss}
C {lab_pin.sym} 680 -1390 0 0 {name=p23 sig_type=std_logic lab=vdd}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 170 -890 0 0 {name=R20
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 170 -810 0 0 {name=R21
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 310 -890 0 0 {name=R22
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 310 -810 0 0 {name=R23
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 150 -780 2 1 {name=p24 sig_type=std_logic lab=vss}
C {lab_pin.sym} 290 -920 2 1 {name=p25 sig_type=std_logic lab=vss}
C {lab_pin.sym} 290 -770 2 1 {name=p26 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 170 -1070 0 0 {name=R24
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 170 -990 0 0 {name=R25
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 310 -1070 0 0 {name=R26
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 310 -990 0 0 {name=R27
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 290 -1100 2 1 {name=p27 sig_type=std_logic lab=vss}
C {lab_pin.sym} 170 -1100 0 0 {name=p28 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 170 -940 0 1 {name=p29 sig_type=std_logic lab=0v9}
C {lab_pin.sym} 680 -1370 0 0 {name=p30 sig_type=std_logic lab=0v9}
C {lab_pin.sym} 680 -1350 2 1 {name=p39 sig_type=std_logic lab=vss}
C {lab_pin.sym} 940 -1190 3 1 {name=p49 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 940 -1150 3 0 {name=p50 sig_type=std_logic lab=vss}
C {lab_pin.sym} 780 -1060 2 1 {name=p4 sig_type=std_logic lab=t0l}
C {lab_pin.sym} 780 -1270 2 1 {name=p51 sig_type=std_logic lab=t0h}
C {lab_pin.sym} 900 -1130 2 1 {name=p52 sig_type=std_logic lab=t0m}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/vbuff.sym} 1470 -1370 0 0 {name=x3}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/anl_switch.sym} 1540 -1170 0 1 {name=x4}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 1440 -1060 0 0 {name=M3
L=0.15
W=2
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 1440 -1270 0 0 {name=M4
L=0.15
W=6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1460 -1310 2 0 {name=p53 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1460 -1020 2 0 {name=p54 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1360 -760 0 0 {name=R28
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1360 -680 0 0 {name=R29
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1500 -760 0 0 {name=R30
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1500 -680 0 0 {name=R31
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1690 -610 3 0 {name=R32
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1750 -610 3 0 {name=R33
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 1340 -680 2 1 {name=p55 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1480 -790 2 1 {name=p56 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1480 -640 2 1 {name=p57 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1360 -940 0 0 {name=R34
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1360 -860 0 0 {name=R35
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1500 -940 0 0 {name=R36
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1500 -860 0 0 {name=R37
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 1480 -970 2 1 {name=p58 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1810 -610 3 0 {name=R38
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 1870 -610 3 0 {name=R39
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 1870 -590 2 0 {name=p59 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1320 -1390 0 0 {name=p64 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1320 -1370 0 0 {name=p65 sig_type=std_logic lab=0v9}
C {lab_pin.sym} 1320 -1350 2 1 {name=p66 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1580 -1190 3 1 {name=p67 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1580 -1150 3 0 {name=p68 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1420 -1060 2 1 {name=p69 sig_type=std_logic lab=t1l}
C {lab_pin.sym} 1420 -1270 2 1 {name=p70 sig_type=std_logic lab=t1h}
C {lab_pin.sym} 1540 -1130 2 1 {name=p71 sig_type=std_logic lab=t1m}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/vbuff.sym} 2110 -1370 0 0 {name=x5}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/anl_switch.sym} 2180 -1170 0 1 {name=x6}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 2080 -1060 0 0 {name=M5
L=0.15
W=2
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 2080 -1270 0 0 {name=M6
L=0.15
W=6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2100 -1310 2 0 {name=p60 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2100 -1020 2 0 {name=p61 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2000 -760 0 0 {name=R40
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2000 -680 0 0 {name=R41
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2140 -760 0 0 {name=R42
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2140 -680 0 0 {name=R43
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2330 -610 3 0 {name=R44
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2390 -610 3 0 {name=R45
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 1980 -680 2 1 {name=p62 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2120 -790 2 1 {name=p63 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2120 -640 2 1 {name=p72 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2000 -940 0 0 {name=R46
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2000 -860 0 0 {name=R47
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2140 -940 0 0 {name=R48
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2140 -860 0 0 {name=R49
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 2120 -970 2 1 {name=p73 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2450 -610 3 0 {name=R50
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2510 -610 3 0 {name=R51
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 2510 -590 2 0 {name=p74 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1960 -1390 0 0 {name=p78 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1960 -1370 0 0 {name=p79 sig_type=std_logic lab=0v9}
C {lab_pin.sym} 1960 -1350 2 1 {name=p80 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2220 -1190 3 1 {name=p81 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2220 -1150 3 0 {name=p82 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2060 -1060 2 1 {name=p83 sig_type=std_logic lab=t2l}
C {lab_pin.sym} 2060 -1270 2 1 {name=p84 sig_type=std_logic lab=t2h}
C {lab_pin.sym} 2180 -1130 2 1 {name=p85 sig_type=std_logic lab=t2m}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/vbuff.sym} 2750 -1370 0 0 {name=x7}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/anl_switch.sym} 2820 -1170 0 1 {name=x8}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 2720 -1060 0 0 {name=M7
L=0.15
W=2
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 2720 -1270 0 0 {name=M8
L=0.15
W=6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2740 -1310 2 0 {name=p86 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2740 -1020 2 0 {name=p87 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2640 -760 0 0 {name=R52
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2640 -680 0 0 {name=R53
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2780 -760 0 0 {name=R54
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2780 -680 0 0 {name=R55
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2970 -610 3 0 {name=R56
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3030 -610 3 0 {name=R57
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 2620 -680 2 1 {name=p88 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2760 -790 2 1 {name=p89 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2760 -640 2 1 {name=p90 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2640 -940 0 0 {name=R58
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2640 -860 0 0 {name=R59
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2780 -940 0 0 {name=R60
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 2780 -860 0 0 {name=R61
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 2760 -970 2 1 {name=p91 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3090 -610 3 0 {name=R62
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3150 -610 3 0 {name=R63
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 3150 -590 2 0 {name=p92 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2600 -1390 0 0 {name=p93 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2600 -1370 0 0 {name=p94 sig_type=std_logic lab=0v9}
C {lab_pin.sym} 2600 -1350 2 1 {name=p95 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2860 -1190 3 1 {name=p96 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2860 -1150 3 0 {name=p97 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2700 -1060 2 1 {name=p98 sig_type=std_logic lab=t3l}
C {lab_pin.sym} 2700 -1270 2 1 {name=p99 sig_type=std_logic lab=t3h}
C {lab_pin.sym} 2820 -1130 2 1 {name=p100 sig_type=std_logic lab=t3m}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/vbuff.sym} 3390 -1370 0 0 {name=x9}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/anl_switch.sym} 3460 -1170 0 1 {name=x10}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 3360 -1060 0 0 {name=M9
L=0.15
W=2
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 3360 -1270 0 0 {name=M10
L=0.15
W=6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3380 -1310 2 0 {name=p101 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 3380 -1020 2 0 {name=p102 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3280 -760 0 0 {name=R64
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3280 -680 0 0 {name=R65
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3420 -760 0 0 {name=R66
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3420 -680 0 0 {name=R67
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3610 -610 3 0 {name=R68
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3670 -610 3 0 {name=R69
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 3260 -680 2 1 {name=p103 sig_type=std_logic lab=vss}
C {lab_pin.sym} 3400 -790 2 1 {name=p104 sig_type=std_logic lab=vss}
C {lab_pin.sym} 3400 -640 2 1 {name=p105 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3280 -940 0 0 {name=R70
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3280 -860 0 0 {name=R71
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3420 -940 0 0 {name=R72
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3420 -860 0 0 {name=R73
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 3400 -970 2 1 {name=p106 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3730 -610 3 0 {name=R74
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3790 -610 3 0 {name=R75
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 3790 -590 2 0 {name=p107 sig_type=std_logic lab=vss}
C {lab_pin.sym} 3240 -1390 0 0 {name=p108 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 3240 -1370 0 0 {name=p109 sig_type=std_logic lab=0v9}
C {lab_pin.sym} 3240 -1350 2 1 {name=p110 sig_type=std_logic lab=vss}
C {lab_pin.sym} 3500 -1190 3 1 {name=p111 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 3500 -1150 3 0 {name=p112 sig_type=std_logic lab=vss}
C {lab_pin.sym} 3340 -1060 2 1 {name=p113 sig_type=std_logic lab=t4l}
C {lab_pin.sym} 3340 -1270 2 1 {name=p114 sig_type=std_logic lab=t4h}
C {lab_pin.sym} 3460 -1130 2 1 {name=p115 sig_type=std_logic lab=t4m}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/vbuff.sym} 4030 -1370 0 0 {name=x11}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/anl_switch.sym} 4100 -1170 0 1 {name=x12}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 4000 -1060 0 0 {name=M11
L=0.15
W=2
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 4000 -1270 0 0 {name=M12
L=0.15
W=6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 4020 -1310 2 0 {name=p116 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 4020 -1020 2 0 {name=p117 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3920 -760 0 0 {name=R77
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3920 -680 0 0 {name=R78
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 4060 -760 0 0 {name=R79
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 4060 -680 0 0 {name=R80
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 3900 -680 2 1 {name=p118 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4040 -790 2 1 {name=p119 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4040 -640 2 1 {name=p120 sig_type=std_logic lab=vss}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3920 -940 0 0 {name=R83
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 3920 -860 0 0 {name=R84
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 4060 -940 0 0 {name=R85
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {/home/ttuser/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/res_high_po_0p69.sym} 4060 -860 0 0 {name=R86
L=0.69
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {lab_pin.sym} 4040 -970 2 1 {name=p121 sig_type=std_logic lab=vss}
C {lab_pin.sym} 3880 -1390 0 0 {name=p123 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 3880 -1370 0 0 {name=p124 sig_type=std_logic lab=0v9}
C {lab_pin.sym} 3880 -1350 2 1 {name=p125 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4140 -1190 3 1 {name=p126 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 4140 -1150 3 0 {name=p127 sig_type=std_logic lab=vss}
C {lab_pin.sym} 3980 -1060 2 1 {name=p128 sig_type=std_logic lab=t5l}
C {lab_pin.sym} 3980 -1270 2 1 {name=p129 sig_type=std_logic lab=t5h}
C {lab_pin.sym} 4100 -1130 2 1 {name=p130 sig_type=std_logic lab=t5m}
C {ipin.sym} 120 -520 0 0 {name=p131 lab=t4m}
C {ipin.sym} 120 -500 0 0 {name=p132 lab=t4l}
C {lab_pin.sym} 120 -520 2 0 {name=p133 sig_type=std_logic lab=t4m}
C {lab_pin.sym} 120 -500 2 0 {name=p134 sig_type=std_logic lab=t4l}
C {ipin.sym} 120 -600 0 0 {name=p135 lab=t5h}
C {ipin.sym} 120 -580 0 0 {name=p136 lab=t5m}
C {ipin.sym} 120 -560 0 0 {name=p137 lab=t5l}
C {ipin.sym} 120 -540 0 0 {name=p138 lab=t4h}
C {lab_pin.sym} 120 -600 2 0 {name=p139 sig_type=std_logic lab=t5h}
C {lab_pin.sym} 120 -580 2 0 {name=p140 sig_type=std_logic lab=t5m}
C {lab_pin.sym} 120 -560 2 0 {name=p141 sig_type=std_logic lab=t5l}
C {lab_pin.sym} 120 -540 2 0 {name=p142 sig_type=std_logic lab=t4h}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/anl_switch.sym} 4340 -1390 0 0 {name=x13}
C {lab_pin.sym} 4300 -1410 1 0 {name=p143 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 4300 -1370 1 1 {name=p144 sig_type=std_logic lab=vss}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/anl_switch.sym} 4340 -1570 0 0 {name=x14}
C {lab_pin.sym} 4300 -1590 1 0 {name=p146 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 4300 -1550 1 1 {name=p147 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4340 -1490 2 1 {name=p148 sig_type=std_logic lab=buffi_conn}
C {lab_pin.sym} 4260 -1570 0 0 {name=p149 sig_type=std_logic lab=0v9}
C {lab_pin.sym} 4420 -1480 2 0 {name=p150 sig_type=std_logic lab=a0}
C {lab_pin.sym} 4340 -1310 2 1 {name=p145 sig_type=std_logic lab=buffo_conn}
C {lab_pin.sym} 120 -220 2 0 {name=p151 sig_type=std_logic lab=buffi_conn}
C {lab_pin.sym} 120 -200 2 0 {name=p153 sig_type=std_logic lab=buffo_conn}
C {ipin.sym} 120 -220 0 0 {name=p154 lab=buffi_conn}
C {ipin.sym} 120 -200 0 0 {name=p155 lab=buffo_conn}
C {/home/ttuser/Documents/adc_dac_ter_alu/src/xschem/anl_switch.sym} 4340 -610 0 0 {name=x15}
C {lab_pin.sym} 4300 -630 1 0 {name=p156 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 4300 -590 1 1 {name=p157 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4340 -530 2 1 {name=p158 sig_type=std_logic lab=DAC6_conn}
C {lab_pin.sym} 4420 -610 2 0 {name=p160 sig_type=std_logic lab=a0}
C {lab_pin.sym} 120 -180 2 0 {name=p122 sig_type=std_logic lab=DAC6_conn}
C {ipin.sym} 120 -180 0 0 {name=p159 lab=DAC6_conn}
